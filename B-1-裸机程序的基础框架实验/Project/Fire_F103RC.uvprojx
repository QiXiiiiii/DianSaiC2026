# Keil uVision project Fire_F103RC.uvprojx, settings and files
target STM32F103RC-Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_F103RC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\User\uart;..\User\dwt;..\User\led;..\User\key;..\User\beep;..\User\tim;..\User\app_test;..\Middlewares\MultiButton;..\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_ll_gpio.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group USER
    ../User/: main.c stm32f1xx_it.c
    ../User/led/: bsp_led.c
    ../User/key/: bsp_key.c
    ../User/beep/: bsp_beep.c
    ../User/uart/: bsp_uart1.c
    ../User/dwt/: bsp_dwt.c
    ../User/tim/: bsp_basic_tim6.c
    ../User/app_test/: app_key.c
  group utils
    ../utils/: data_test.c task_simple.c
  group MultiButton
    ../Middlewares/MultiButton/: multi_button.c
  group DOC
    ../Doc/: readme.txt
